# Keil uVision project Bootloader.uvproj, settings and files
target Bootloader (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ACU_Bootloader +hex
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_MD
  c include: .\Include
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s
  group System
    ./C/: core_cm3.c system_stm32f10x.c
  group Hardware
    ./C/: serial.c programm.c
  group App
    ./C/: main.c crc32.c
