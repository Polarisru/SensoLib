# Keil uVision project Rocket.uvproj, settings and files
target Rocket Debug (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Rocket
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, STM32F103xB
  c misc: --C99
  c include: .\Include;.\STM32F10x_StdPeriph_Driver\inc;.\FatFs;.\STM32_USB-FS-Device_Driver\inc;.\USB;.\FreeRTOS\Include;.\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./: startup_stm32f10x_md.s
    ./CMSIS/: system_stm32f1xx.c
    ./C/: RTX_Conf_CM.c
  group Source Code
    ./C/: crc32.c global.c main.c version.c utils.c sensors.c comm.c gps.c nmea.c bt.c timedate.c kbd.c usb2com.c sim800.c
  group Sensors
    ./C/: bmp180.c tmp102.c lm75a.c hmc5883l.c mpu6050.c ds3231.c mfrc522.c
  group Hardware
    ./C/: m24xx.c eeprom.c timer.c adc.c i2c.c rs232.c sdspi.c rtc.c tm1637.c spi.c
  group USB
    ./USB/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Standard Peripherals
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FatFS
    ./FatFs/: diskio.c ff.c
  group STM32_USB-FS-Device
    ./STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group FreeRTOS
    ./FreeRTOS/: heap_4.c croutine.c event_groups.c list.c port.c queue.c tasks.c timers.c
  group Documentation
    ./Docs/: SIM800.txt
target Rocket Boot (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Rocket_Boot +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, BOOT
  c include: .\Include;.\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8001000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x5000
